# Keil uVision project STM32.uvprojx, settings and files
target STM32_USART1 (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: .\user;.\Algorithm;.\MyLib;.\FreeRTOS\include;.\FreeRTOS\port\MemMang;.\FreeRTOS\port\RVDS\ARM_CM3;.\FreeRTOS\src;.\TASK;.\Library\inc;.\startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./startup/: startup_stm32f10x_cl.s
  group User
    ./user/: main.c stm32f10x_it.c FreeRTOSConfig.h system_stm32f10x.c
  group TASK
    ./TASK/: chassis_task.c state_task.c start_task.c
  group Algorithm
    ./Algorithm/: pid.c algorithmOfCRC.c
  group MyLib
    ./MyLib/: can1.c can2.c led.c delay.c drv_dma.c nvic.c remote.c tim.c usart.c usart1.c usart2.c usart3.c uart4.c uart5.c JudgeSend.c
  group CMSIS
    ./user/: core_cm3.c
  group Library
    ./Library/SRC/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group FreeRTOS/Src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ./FreeRTOS/port/MemMang/: heap_4.c
    ./FreeRTOS/port/RVDS/ARM_CM3/: port.c
